FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-aesys-uboot-patch-1900x1200-lcd.patch \
           "file://0002-aesys-uboot-patch-seco-config-fbpix.patch \
           "file://0003-aesys-uboot-patch-fbpix-lcd.patch "
	

