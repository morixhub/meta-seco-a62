FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"
SRC_URI += "file://0002-aesys-gst-pipeline-force-system-clock.patch"

